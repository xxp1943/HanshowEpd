# IAR project EPD_Clock.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\Src\Main; ..\Src\Module
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group Main
    ../Src/Main/: common.c common.h def.h main.c
  group Module
    ../Src/Module/: epd.c epd.h flash.c flash.h font.c font.h RTC_Calendar.h shell.c softspi3w.c softspi3w.h softuart.c softuart.h ucbspi.c ucbspi.h
    ../Src/IAR_S/: RTC_Calendar.s43
